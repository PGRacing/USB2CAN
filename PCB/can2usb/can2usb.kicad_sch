File: PCB/can2usb/can2usb.kicad_sch (KiCad schematic)
At the start: 40 parts

Commit message: Local code copy
Parts:
- gave numbers to parts that had none: 36
